# Repository ilkercakir/IOBoardV0

File README.md:

# IOBoardV0
IOT Control Board Console Application

## KiCad design PCB/IOBoardV0/Actuator_Relay.kicad_pcb

Parts:
C1: 10uF
C2: 100uF
D1: LED
D2: DIODE
J1, J2: RJ45_2
K1: RELAY_J9906
P1: KLEMENS_1
P2: CONN_8X2
Q1: BC557; TO92
Q2: 2N2222A; TO92
R1: 10K
R2: 22K
R3: 680
R4, R5: 2.2K

Connections:
GND: C1.2, C2.2, J2.2, Q2.1 (E), R3.2
unnamed: Q1.1 (C), R4.2
unnamed: Q1.2 (B), R1.2, R2.2
unnamed: Q2.2 (B), R3.1, R4.1
unnamed: D1.1 (A), R5.2
unnamed: K1.3 (C1), P1.1
unnamed: K1.5 (T1), P1.2 (PM)
unnamed: J1.8, P2.16
unnamed: J1.7, P2.14
unnamed: J1.6, P2.12
unnamed: J1.5, P2.10
unnamed: J1.4, P2.8
unnamed: J1.3, P2.6
unnamed: J1.2, P2.4
unnamed: J1.1, P2.2
unnamed: D1.2 (K), D2.1 (A), K1.2 (COIL1), Q2.3 (C)
unnamed: P2.1, P2.3, P2.5, P2.7, P2.9, P2.11, P2.13, P2.15, R2.1
VCC: C1.1, C2.1, D2.2 (K), J2.1, K1.4 (COIL2), Q1.3 (E), R1.1, R5.1

Board: 2 copper layers, 53.8 x 36.1 mm, 16 parts (0 on the bottom side), 18 nets.

## KiCad design PCB/IOBoardV0/WaterLevel.kicad_pcb

Parts:
GS2, GS3, GS4, GS5, GS6, GS7, GS8: GS2
J1: RJ45_2

Connections:
GND: GS2.2 (G2), GS3.2 (G2), GS4.2 (G2), GS5.2 (G2), GS6.2 (G2), GS7.2 (G2), GS8.2 (G2), J1.1
unnamed: GS5.1 (G1), J1.5
unnamed: GS2.1 (G1), J1.2
unnamed: GS3.1 (G1), J1.3
unnamed: GS4.1 (G1), J1.4
unnamed: GS6.1 (G1), J1.6
unnamed: GS7.1 (G1), J1.7
unnamed: GS8.1 (G1), J1.8

Board: 2 copper layers, 19.9 x 120.8 mm, 8 parts (0 on the bottom side), 8 nets.

## KiCad design PCB/IOBoardV0/IOBoardV0.kicad_pcb

Parts:
C1, C2, C3, C4: 10uF
D1: DIODE
D2, D3: LED
J2, J3, J4, J5, J6, J7, J8, J9: RJ45_2
P1: RASPBERRY_HAT
R1, R2, R3, R4: 10K
R5: 2.2K
R6: 3.3K
U1: 74LS04
U2: 74LS138
U3: 74LS164
U4: 74LS373
U5: 74LS74
U6: 74LS165

Connections:
/A0: J2.1, J3.1, J4.1, J5.1, U4.2 (O0)
/A1: J2.2, J3.2, J4.2, J5.2, U4.5 (O1)
/A2: J2.3, J3.3, J4.3, J5.3, U4.6 (O2)
/A3: J2.4, J3.4, J4.4, J5.4, U4.9 (O3)
/A4: J2.5, J3.5, J4.5, J5.5, U4.12 (O4)
/A5: J2.6, J3.6, J4.6, J5.6, U4.15 (O5)
/A6: J2.7, J3.7, J4.7, J5.7, U4.16 (O6)
/A7: J2.8, J3.8, J4.8, J5.8, U4.19 (O7)
/S0: J6.1, J7.1, J8.1, J9.1, U6.11 (P0)
/S1: J6.2, J7.2, J8.2, J9.2, U6.12 (P1)
/S2: J6.3, J7.3, J8.3, J9.3, U6.13 (P2)
/S3: J6.4, J7.4, J8.4, J9.4, U6.14 (P3)
/S4: J6.5, J7.5, J8.5, J9.5, U6.3 (P4)
/S5: J6.6, J7.6, J8.6, J9.6, U6.4 (P5)
/S6: J6.7, J7.7, J8.7, J9.7, U6.5 (P6)
/S7: J6.8, J7.8, J8.8, J9.8, U6.6 (P7)
GND: C1.2, C2.2, C3.2, C4.2, P1.6, R3.2, R6.2, U1.7 (GND), U2.4 (E1), U2.5 (E2), U2.8 (GND), U3.7 (GND), U4.10 (GND), U5.7 (GND), U6.8 (GND), U6.15 (CE)
unnamed: U5.6 (~Q), U6.10 (Ds)
unnamed: P1.18, R5.2, R6.1
unnamed: D3.2 (K), U5.9 (Q)
unnamed: U2.13 (O2), U6.1 (Pl)
unnamed: U2.12 (O3), U6.2 (CP)
unnamed: R5.1, U6.7 (~Q7)
unnamed: U2.10 (O5), U5.11 (Cp)
unnamed: U2.11 (O4), U5.3 (Cp)
unnamed: U1.11, U2.14 (O1)
unnamed: U2.15 (O0), U3.8 (CLK)
unnamed: U3.5 (Q2), U4.7 (D2)
unnamed: U3.10 (Q4), U4.13 (D4)
unnamed: U3.11 (Q5), U4.14 (D5)
unnamed: U3.3 (Q0), U4.3 (D0)
unnamed: U3.4 (Q1), U4.4 (D1)
unnamed: P1.15, R2.2, U1.5
unnamed: U1.6, U2.6 (E3)
unnamed: P1.11, U2.1 (A0)
unnamed: U1.2, U1.3
unnamed: P1.13, U2.3 (A2)
unnamed: P1.12, U2.2 (A1)
unnamed: U3.13 (Q7), U4.18 (D7)
unnamed: U3.12 (Q6), U4.17 (D6)
unnamed: U3.6 (Q3), U4.8 (D3)
unnamed: P1.16, U1.9
unnamed: U4.1 (OE), U5.5 (Q)
unnamed: U1.10, U4.11 (LE)
unnamed: U1.8, U3.1 (A), U5.2 (D), U5.12 (D)
unnamed: D2.2 (K), R3.1
unnamed: C1.1, D1.1 (A), R1.2, U1.1
unnamed: D3.1 (A), R4.2
unnamed: U1.4, U5.4 (Sd), U5.10 (Sd)

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
Board: 2 copper layers, 87.8 x 79.9 mm, 28 parts (0 on the bottom side), 50 nets.

## KiCad design PCB/IOBoardV0/Sensor_Level.kicad_pcb

Parts:
C1, C2, C3: 1uF
D1: LED
J1, J2, J3: RJ45_2
P1: CONN_8X2
R1, R2, R17: 10K
R3, R5, R7, R9, R11, R13, R15: 47K
R4, R6, R8, R10, R12, R14, R16: 100K
U1, U2: LM324
U3: 74LS148

Connections:
GND: C1.2, C2.2, C3.2, J1.2, J1.4, J1.6, J1.8, J3.1, R2.2, R17.2, U1.11 (V-), U2.11 (V-), U3.5 (EI), U3.8 (GND), U3.10 (IO)
unnamed: R12.2, U2.7, U3.2 (I5)
unnamed: R16.2, U2.14, U3.4 (I7)
unnamed: R14.2, U2.8, U3.3 (I6)
unnamed: R10.2, U2.1, U3.1 (I4)
unnamed: R8.2, U1.14, U3.13 (I3)
unnamed: P1.5, U3.6 (S2)
unnamed: D1.2 (K), R17.1
unnamed: P1.1, U3.9 (S0)
unnamed: J2.6, P1.12
unnamed: J2.5, P1.10
unnamed: J2.4, P1.8
unnamed: J2.3, P1.6
unnamed: J2.2, P1.4
unnamed: J2.1, P1.2
unnamed: J2.8, P1.16
unnamed: P1.3, U3.7 (S1)
unnamed: J2.7, P1.14
unnamed: J3.7, R13.2, R14.1, U2.10 (+)
unnamed: J3.6, R11.2, R12.1, U2.5 (+)
unnamed: J3.5, R9.2, R10.1, U2.3 (+)
unnamed: J3.4, R7.2, R8.1, U1.12 (+)
unnamed: J3.3, R5.2, R6.1, U1.10 (+)
unnamed: R6.2, U1.8, U3.12 (I2)
unnamed: R4.2, U1.7, U3.11 (I1)
unnamed: J3.8, R15.2, R16.1, U2.12 (+)
unnamed: R1.2, R2.1, U1.3 (+)
unnamed: J3.2, R3.2, R4.1, U1.5 (+)
unnamed: U1.1, U1.2 (-), U1.6 (-), U1.9 (-), U1.13 (-), U2.2 (-), U2.6 (-), U2.9 (-), U2.13 (-)
VCC: C1.1, C2.1, C3.1, D1.1 (A), J1.1, J1.3, J1.5, J1.7, R1.1, R3.1, R5.1, R7.1, R9.1, R11.1, R13.1, R15.1, U1.4 (V+), U2.4 (V+), U3.16 (VCC)

Board: 2 copper layers, 48.8 x 69.2 mm, 28 parts (0 on the bottom side), 30 nets.

## KiCad design PCB/IOBoardV0/Power.kicad_pcb

Parts:
C1: 100uF
D1: LED
J1: JACK_2P
J2, J3, J4, J5, J6, J7, J8, J9: RJ45_2
R1: 10K

Connections:
GND: C1.2, D1.2 (K), J1.1, J1.2, J2.2, J2.4, J2.6, J2.8, J3.2, J3.4, J3.6, J3.8, J4.2, J4.4, J4.6, J4.8, J5.2, J5.4, J5.6, J5.8, J6.2, J6.4, J6.6, J6.8, J7.2, J7.4, J7.6, J7.8, J8.2, J8.4, J8.6, J8.8, J9.2, J9.4, J9.6, J9.8
unnamed: D1.1 (A), R1.2
VCC: C1.1, J1.3, J2.1, J2.3, J2.5, J2.7, J3.1, J3.3, J3.5, J3.7, J4.1, J4.3, J4.5, J4.7, J5.1, J5.3, J5.5, J5.7, J6.1, J6.3, J6.5, J6.7, J7.1, J7.3, J7.5, J7.7, J8.1, J8.3, J8.5, J8.7, J9.1, J9.3, J9.5, J9.7, R1.1

Board: 2 copper layers, 34.3 x 83.9 mm, 12 parts (0 on the bottom side), 3 nets.

## Commit log

2019-12-25 Create IOBoard
2020-01-19 Create i
2020-04-24 Create x
